# Adapt upstream recipe to kirkstone
SRC_URI = "git://github.com/KhronosGroup/Vulkan-Headers.git;branch=main;protocol=https"
S = "${WORKDIR}/git"
