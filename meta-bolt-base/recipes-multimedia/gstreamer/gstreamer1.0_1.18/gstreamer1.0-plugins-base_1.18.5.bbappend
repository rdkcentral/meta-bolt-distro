SRC_URI:remove = "file://0001-gst-plugins-base-stubs-soft.h-not-existing-compilati.patch"
