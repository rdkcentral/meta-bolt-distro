FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-ICU-22813-Rise-the-size-of-the-buffers-used-for-the-.patch"
