inherit base-bolt-image
