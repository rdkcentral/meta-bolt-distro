SUMMARY = "bolt image for skeleton"

inherit base-bolt-image

IMAGE_INSTALL += "skeleton"
